# Keil uVision project EasyFOC.uvprojx, settings and files
target EasyFOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EasyFOC +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\SYSTEM;..\Libraries\SimpleFOC;..\Libraries\U8G2;..\HARDWARE\ADC;..\HARDWARE\AS5600;..\HARDWARE\BEEPER;..\HARDWARE\LED;..\HARDWARE\MultiButton;..\HARDWARE\OLED;..\HARDWARE\SPI;..\HARDWARE\MyIIC;..\HARDWARE\AS5047P;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/OLED/: oled.c oled.h OLED_User.c OLED_User.h
    ../HARDWARE/BEEPER/: BEEPER.c BEEPER.h
    ../HARDWARE/MultiButton/: multi_button.c multi_button.h multi_button_user.c multi_button_user.h
    ../HARDWARE/AS5600/: AS5600.c AS5600.h
    ../HARDWARE/ADC/: MyADC.c MyADC.h
    ../HARDWARE/MyIIC/: MyIIC2.c MyIIC2.h MyIIC_HW.c MyIIC_HW.h
    ../HARDWARE/AS5047P/: AS5047P.c AS5047P.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: CommonMacro.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_flash.c stm32f4xx_adc.c
  group U8G2
    ../Libraries/U8G2/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_Init.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_a2printer.c u8x8_d_sh1107.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group SimpleFOC
    ../Libraries/SimpleFOC/: BLDCMotor.c BLDCMotor.h foc_utils.c foc_utils.h FOCMotor.c FOCMotor.h FOCBaseConfig.c FOCBaseConfig.h FOCuser_Inc.h lowpass_filter.c lowpass_filter.h pid.c pid.h CurrentSense.c CurrentSense.h InlineCurrentSense.c InlineCurrentSense.h MagneticSensor.c MagneticSensor.h
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
